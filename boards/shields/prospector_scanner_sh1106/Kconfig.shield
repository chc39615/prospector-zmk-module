## boards/shields/prospector_scanner_sh1106/Kconfig.shield
```kconfig
config SHIELD_PROSPECTOR_SCANNER_SH1106
    def_bool $(shields_list_contains,prospector_scanner_sh1106)
```
